# Keil uVision project 大王学32.uvprojx, settings and files
target 32F1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 大王学32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\SYSTEM;..\STM32F10x_FWLib\inc;..\led;..\CORE;..\exti;..\key;..\time;..\dma;..\OLED;..\shell;..\step-motor;..\ui
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group fwilb
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_dma.c
  group system
    ../SYSTEM/: delay.c sys.c usart1.c
  group led
    ../led/: led.c
  group exti
    ../exti/: exti.c
  group key
    ../key/: key.c
  group time
    ../time/: time.c
  group oled
    ../OLED/: oled.c
  group shell
    ../shell/: shell.c shell_config.c shell_str.c
  group step_motor
    ../step-motor/: step_motor.c
  group ui
    ../ui/: display.c
